# Keil uVision project pulser.uvprojx, settings and files
target stm32_G474QETx (6230000::V6.23::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pulser +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx,USE_FULL_LL_DRIVER
  c include: ..\users;..\drivers\stm32g4xx-hal-driver\Inc;..\drivers\stm32g4xx-hal-driver\Inc\Legacy;..\drivers\cmsis-device-g4\Include;..\utilities;..\utilities\math;..\utilities\filter;..\devices\inc;..\modules;..\drivers\bsp\stm32\hal;..\drivers\bsp\stm32\ll;..\middlewares\RTT;..\test;..\middlewares\proto;..\applications
  asm include: ..\users;..\middlewares\RTT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\pulser.sct
  group user
    ../users/: main.c board.c stm32g4xx_hal_conf.h bsp_conf.h sys_conf.h SEGGER_RTT_Conf.h
  group applications
    ../applications/: custom_slave.c major_logic.c cmd_handler.c
  group modules
    ../modules/: data_mgmt.c ecg_sync.c ocd.c pulse_engine.c safety.c
  group middlewares/SEGGER_RTT
    ../middlewares/RTT/: SEGGER_RTT.c
  group middlewares/proto
    ../middlewares/proto/: proto_custom.c proto.c
  group devices
    ../devices/: gpio.c mtd_core.c serial.c adc.c hwtimer.c dac.c wdg.c
  group drivers/bsp
    ../drivers/bsp/stm32/hal/: bsp_adc.c bsp_comp.c bsp_dac.c bsp_dwt.c bsp_flash.c bsp_flash_test.c bsp_gpio.c bsp_hwtimer.c bsp_it.c bsp_iwdg.c bsp_sram.c bsp_tim.c bsp_usart.c
    ../drivers/bsp/stm32/ll/: bsp_hrtim.c
  group drivers/stm32g4xx_hal
    ../drivers/stm32g4xx-hal-driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_comp.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_fmac.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_sram.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_ll_fmc.c stm32g4xx_ll_gpio.c stm32g4xx_ll_hrtim.c
  group drivers/cmsis
    ../drivers/cmsis-device-g4/Source/Templates/: system_stm32g4xx.c
    ../drivers/cmsis-device-g4/Source/Templates/arm/: startup_stm32g474xx.s
  group utilities
    ../utilities/: kfifo.c kmutex.c atomic.c log.c stimer.c sort_algo.c crc.c
  group test
    ../test/: uart_test.c gpio_test.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.1
